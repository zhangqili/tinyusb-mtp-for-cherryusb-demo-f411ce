# Keil uVision project tinyusb-mtp-for-cherryusb-demo-f411ce.uvprojx, settings and files
target tinyusb-mtp-for-cherryusb-demo-f411ce (6240000::V6.24::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: tinyusb-mtp-for-cherryusb-demo-f411ce +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE,CMSIS_device_header=<stm32f4xx.h>
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\CherryUSB\core;..\CherryUSB\common;..\CherryUSB\class\hid;..\CherryUSB\class\midi;..\CherryUSB\class\hub;..\CherryUSB\port\dwc2;..\littlefs;..\mtp;..\usb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group CherryUSB
    ../CherryUSB/core/: usbd_core.c
    ../CherryUSB/class/hid/: usbd_hid.c
    ../CherryUSB/port/dwc2/: usb_dc_dwc2.c usb_glue_st.c
  group littlefs
    ../littlefs/: lfs.c lfs_util.c
  group usb
    ../usb/: usbd_user.c
  group mtp
    ../mtp/: mtp_device.c mtp_fs_conv.c mtp_fs_port.c usbd_mtp.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:ITM 1.1.0, CMSIS:CORE 6.1.1
